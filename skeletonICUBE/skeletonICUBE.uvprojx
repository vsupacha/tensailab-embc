# Keil uVision project skeletonICUBE.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: skeletonICUBE
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L072xx,USE_B_L072Z_LRWAN1,USE_HAL_DRIVER, REGION_AS923 LOW_POWER_DISABLE DEBUG
  c include: ..\skeletonICUBE;.\inc;.\Drivers\STM32L0xx_HAL_Driver\Inc;.\Drivers\B-L072Z-LRWAN1;.\Drivers\MLM32L07X01;.\Drivers\sx1276;.\Drivers\CMSIS\Include;.\Lora\Core;.\Lora\Crypto;.\Lora\Mac;.\Lora\Phy;.\Lora\Utilities
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Source
    ./src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c vcom.c
    ./inc/: Commissioning.h
  group B-L072Z-LRWAN1
    ./Drivers/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Lora
    ./Lora/Core/: lora.c lora-test.c
    ./Lora/Crypto/: aes.c cmac.c
    ./Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
    ./Lora/Mac/region/: Region.c RegionAS923.c RegionCommon.c
    ./Lora/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c
  group MLM32L07X01
    ./Drivers/MLM32L07X01/: mlm32l07x01.c
  group SX1276
    ./Drivers/sx1276/: sx1276.c
  group HAL
    ./Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rtc.c stm32l0xx_hal_uart.c stm32l0xx_hal_dma.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_spi.c stm32l0xx_hal_pwr_ex.c
  group CMSIS
    ./Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ./Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l072xx.s
