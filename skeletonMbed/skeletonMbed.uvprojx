# Keil uVision project skeletonMbed.uvprojx, settings and files
target skeletonMbed (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: skeletonMbed
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -D__CORTEX_M0PLUS --split_sections -DTARGET_DISCO_L072CZ_LRWAN1 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DTARGET_STM32L072CZ -DTARGET_FF_ARDUINO -c -DTARGET_M0P -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 -DTARGET_LIKE_CORTEX_M0 -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DDEVICE_I2C_ASYNCH=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DARM_MATH_CM0PLUS --cpu=Cortex-M0 -DMBED_BUILD_TIMESTAMP=1525923095.7 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DDEVICE_TRNG=1 -DTARGET_FAMILY_STM32 -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_STM32L0 -DTARGET_STM32L072xZ -DTARGET_STM32L072xx --apcs=interwork -DTARGET_CORTEX -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .;mbed-semtech-lora-rf-drivers;mbed-semtech-lora-rf-drivers/SX1272;mbed-semtech-lora-rf-drivers/SX1272/registers;mbed-semtech-lora-rf-drivers/SX1276;mbed-semtech-lora-rf-drivers/SX1276/registers;mbed-os/.;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/greentea-client/source;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/source;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/source;mbed-os/features/frameworks/utest/utest;mbed-os/features/mbedtls;mbed-os/features/mbedtls/importer;mbed-os/features/mbedtls/inc;mbed-os/features/mbedtls/inc/mbedtls;mbed-os/features/mbedtls/src;mbed-os/features/mbedtls/platform;mbed-os/features/mbedtls/platform/inc;mbed-os/features/mbedtls/platform/src;mbed-os/features/mbedtls/targets;mbed-os/features/mbedtls/targets/TARGET_STM;mbed-os/features/nanostack;mbed-os/features/storage;mbed-os/features/netsocket;mbed-os/features/netsocket/cellular;mbed-os/features/netsocket/cellular/generic_modem_driver;mbed-os/features/filesystem;mbed-os/features/filesystem/bd;mbed-os/features/filesystem/fat;mbed-os/features/filesystem/fat/ChaN;mbed-os/features/filesystem/littlefs;mbed-os/features/filesystem/littlefs/littlefs;mbed-os/features/cellular;mbed-os/features/cellular/easy_cellular;mbed-os/features/cellular/framework;mbed-os/features/cellular/framework/API;mbed-os/features/cellular/framework/AT;mbed-os/features/cellular/framework/common;mbed-os/features/cellular/framework/targets;mbed-os/features/cellular/framework/targets/QUECTEL;mbed-os/features/cellular/framework/targets/QUECTEL/BC95;mbed-os/features/cellular/framework/targets/QUECTEL/BG96;mbed-os/features/cellular/framework/targets/TELIT;mbed-os/features/cellular/framework/targets/TELIT/HE910;mbed-os/features/cellular/framework/targets/UBLOX;mbed-os/features/cellular/framework/targets/UBLOX/LISA_U;mbed-os/features/lorawan;mbed-os/features/lorawan/lorastack;mbed-os/features/lorawan/lorastack/mac;mbed-os/features/lorawan/lorastack/phy;mbed-os/features/lorawan/system;mbed-os/features/nvstore;mbed-os/features/nvstore/source;mbed-os/cmsis;mbed-os/cmsis/TARGET_CORTEX_M;mbed-os/drivers;mbed-os/events;mbed-os/events/equeue;mbed-os/rtos;mbed-os/rtos/TARGET_CORTEX;mbed-os/rtos/TARGET_CORTEX/rtx4;mbed-os/rtos/TARGET_CORTEX/rtx5;mbed-os/rtos/TARGET_CORTEX/rtx5/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_M0P;mbed-os/rtos/TARGET_CORTEX/rtx5/Source;mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M;mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_ARM;mbed-os/hal;mbed-os/hal/storage_abstraction;mbed-os/platform;mbed-os/targets;mbed-os/targets/TARGET_STM;mbed-os/targets/TARGET_STM/TARGET_STM32L0;mbed-os/targets/TARGET_STM/TARGET_STM32L0/device;mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ;mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ/TARGET_DISCO_L072CZ_LRWAN1;mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ/device;mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ/device/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M0PLUS,-DARM_MATH_CM0PLUS
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ/device/TOOLCHAIN_ARM_STD/stm32l072xz.sct
  link misc: --show_full_path
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/features/mbedtls/targets/TARGET_STM/: aes_alt.c aes_alt.h md5_alt.c md5_alt.h sha1_alt.c sha1_alt.h sha256_alt.c sha256_alt.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_overrides.c mbed_rtx.h nvic_addr.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h critical_section_api.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L0/: analogin_device.c analogout_device.c common_objects.h device.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h
    mbed-os/features/cellular/easy_cellular/: APN_db.h CellularConnectionFSM.cpp CellularConnectionFSM.h EasyCellularConnection.cpp EasyCellularConnection.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/features/cellular/framework/AT/: AT_CellularBase.cpp AT_CellularBase.h AT_CellularDevice.cpp AT_CellularDevice.h AT_CellularInformation.cpp AT_CellularInformation.h AT_CellularNetwork.cpp AT_CellularNetwork.h AT_CellularPower.cpp AT_CellularPower.h AT_CellularSIM.cpp AT_CellularSIM.h AT_CellularSMS.cpp AT_CellularSMS.h AT_CellularStack.cpp AT_CellularStack.h ATHandler.cpp ATHandler.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h ExhaustibleBlockDevice.cpp ExhaustibleBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ObservingBlockDevice.cpp ObservingBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h ReadOnlyBlockDevice.cpp ReadOnlyBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/features/netsocket/: CellularBase.h CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_ppp.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    mbed-os/features/cellular/framework/API/: CellularDevice.h CellularInformation.h CellularNetwork.h CellularPower.h CellularSIM.h CellularSMS.h
    mbed-os/features/cellular/framework/common/: CellularList.h CellularLog.h CellularTargets.h CellularUtil.cpp CellularUtil.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ/device/: cmsis.h cmsis_nvic.h hal_tick.h objects.h stm32l072xx.h stm32l0xx.h system_stm32l0xx.h
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/rtos/: ConditionVariable.cpp ConditionVariable.h EventFlags.cpp EventFlags.h Kernel.cpp Kernel.h Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/features/filesystem/fat/ChaN/: diskio.h ff.cpp ff.h ffconf.h ffunicode.cpp integer.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    mbed-os/features/mbedtls/targets/: hash_wrappers.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_M0P/: irq_cm0.S
    mbed-os/features/filesystem/littlefs/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
    mbed-os/features/filesystem/littlefs/: LittleFileSystem.cpp LittleFileSystem.h
    mbed-os/features/lorawan/lorastack/phy/: lora_phy_ds.h LoRaPHY.cpp LoRaPHY.h LoRaPHYAS923.cpp LoRaPHYAS923.h LoRaPHYAU915.cpp LoRaPHYAU915.h LoRaPHYCN470.cpp LoRaPHYCN470.h LoRaPHYCN779.cpp LoRaPHYCN779.h LoRaPHYEU433.cpp LoRaPHYEU433.h LoRaPHYEU868.cpp LoRaPHYEU868.h LoRaPHYIN865.cpp LoRaPHYIN865.h LoRaPHYKR920.cpp LoRaPHYKR920.h LoRaPHYUS915.cpp LoRaPHYUS915.h LoRaPHYUS915Hybrid.cpp LoRaPHYUS915Hybrid.h
    mbed-os/features/lorawan/lorastack/mac/: LoRaMac.cpp LoRaMac.h LoRaMacChannelPlan.cpp LoRaMacChannelPlan.h LoRaMacCommand.cpp LoRaMacCommand.h LoRaMacCrypto.cpp LoRaMacCrypto.h LoRaMacMcps.cpp LoRaMacMcps.h LoRaMacMib.cpp LoRaMacMib.h LoRaMacMlme.cpp LoRaMacMlme.h
    mbed-os/features/lorawan/: LoRaRadio.h LoRaWANBase.h LoRaWANInterface.cpp LoRaWANInterface.h LoRaWANStack.cpp LoRaWANStack.h
    mbed-os/features/lorawan/system/: lorawan_data_structures.h LoRaWANTimer.cpp LoRaWANTimer.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/: mbed.h
    mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp SysTimer.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.c mbed_rtx_fault_handler.h
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/nvstore/source/: nvstore.cpp nvstore.h
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.cpp OnboardCellularInterface.h PPPCellularInterface.cpp PPPCellularInterface.h UARTCellularInterface.cpp UARTCellularInterface.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ/TARGET_DISCO_L072CZ_LRWAN1/: PeripheralNames.h PeripheralPins.c PinNames.h system_clock.c
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/features/cellular/framework/targets/QUECTEL/BC95/: QUECTEL_BC95.cpp QUECTEL_BC95.h QUECTEL_BC95_CellularNetwork.cpp QUECTEL_BC95_CellularNetwork.h QUECTEL_BC95_CellularPower.cpp QUECTEL_BC95_CellularPower.h QUECTEL_BC95_CellularSIM.cpp QUECTEL_BC95_CellularSIM.h QUECTEL_BC95_CellularStack.cpp QUECTEL_BC95_CellularStack.h
    mbed-os/features/cellular/framework/targets/QUECTEL/BG96/: QUECTEL_BG96.cpp QUECTEL_BG96.h QUECTEL_BG96_CellularNetwork.cpp QUECTEL_BG96_CellularNetwork.h QUECTEL_BG96_CellularStack.cpp QUECTEL_BG96_CellularStack.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.c rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c RTX_Config.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L0/TARGET_STM32L072xZ/device/TOOLCHAIN_ARM_STD/: startup_stm32l072xx.S
    mbed-os/targets/TARGET_STM/TARGET_STM32L0/device/: stm32_hal_legacy.h stm32l0xx_hal.c stm32l0xx_hal.h stm32l0xx_hal_adc.c stm32l0xx_hal_adc.h stm32l0xx_hal_adc_ex.c stm32l0xx_hal_adc_ex.h stm32l0xx_hal_comp.c stm32l0xx_hal_comp.h stm32l0xx_hal_comp_ex.c stm32l0xx_hal_comp_ex.h stm32l0xx_hal_conf.h stm32l0xx_hal_cortex.c stm32l0xx_hal_cortex.h stm32l0xx_hal_crc.c stm32l0xx_hal_crc.h stm32l0xx_hal_crc_ex.c stm32l0xx_hal_crc_ex.h stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp.h stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_cryp_ex.h stm32l0xx_hal_dac.c stm32l0xx_hal_dac.h stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dac_ex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.c stm32l0xx_hal_dma.h stm32l0xx_hal_firewall.c stm32l0xx_hal_firewall.h stm32l0xx_hal_flash.c stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.c stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_i2s.c stm32l0xx_hal_i2s.h stm32l0xx_hal_irda.c stm32l0xx_hal_irda.h stm32l0xx_hal_irda_ex.h stm32l0xx_hal_iwdg.c stm32l0xx_hal_iwdg.h stm32l0xx_hal_lcd.c stm32l0xx_hal_lcd.h stm32l0xx_hal_lptim.c stm32l0xx_hal_lptim.h stm32l0xx_hal_lptim_ex.h stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd.h stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pcd_ex.h stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_rng.c stm32l0xx_hal_rng.h stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc.h stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rtc_ex.h stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard.h stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smartcard_ex.h stm32l0xx_hal_smbus.c stm32l0xx_hal_smbus.h stm32l0xx_hal_spi.c stm32l0xx_hal_spi.h stm32l0xx_hal_tim.c stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tim_ex.h stm32l0xx_hal_tsc.c stm32l0xx_hal_tsc.h stm32l0xx_hal_uart.c stm32l0xx_hal_uart.h stm32l0xx_hal_uart_ex.c stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart.c stm32l0xx_hal_usart.h stm32l0xx_hal_usart_ex.h stm32l0xx_hal_wwdg.c stm32l0xx_hal_wwdg.h stm32l0xx_ll_adc.c stm32l0xx_ll_adc.h stm32l0xx_ll_bus.h stm32l0xx_ll_comp.c stm32l0xx_ll_comp.h stm32l0xx_ll_cortex.h stm32l0xx_ll_crc.c stm32l0xx_ll_crc.h stm32l0xx_ll_crs.c stm32l0xx_ll_crs.h stm32l0xx_ll_dac.c stm32l0xx_ll_dac.h stm32l0xx_ll_dma.c stm32l0xx_ll_dma.h stm32l0xx_ll_exti.c stm32l0xx_ll_exti.h stm32l0xx_ll_gpio.c stm32l0xx_ll_gpio.h stm32l0xx_ll_i2c.c stm32l0xx_ll_i2c.h stm32l0xx_ll_iwdg.h stm32l0xx_ll_lptim.c stm32l0xx_ll_lptim.h stm32l0xx_ll_lpuart.c stm32l0xx_ll_lpuart.h stm32l0xx_ll_pwr.c stm32l0xx_ll_pwr.h stm32l0xx_ll_rcc.c stm32l0xx_ll_rcc.h stm32l0xx_ll_rng.c stm32l0xx_ll_rng.h stm32l0xx_ll_rtc.c stm32l0xx_ll_rtc.h stm32l0xx_ll_spi.c stm32l0xx_ll_spi.h stm32l0xx_ll_system.h stm32l0xx_ll_tim.c stm32l0xx_ll_tim.h stm32l0xx_ll_usart.c stm32l0xx_ll_usart.h stm32l0xx_ll_utils.c stm32l0xx_ll_utils.h stm32l0xx_ll_wwdg.h system_stm32l0xx.c
    mbed-os/features/cellular/framework/targets/TELIT/HE910/: TELIT_HE910.cpp TELIT_HE910.h TELIT_HE910_CellularNetwork.cpp TELIT_HE910_CellularNetwork.h TELIT_HE910_CellularPower.cpp TELIT_HE910_CellularPower.h
    mbed-os/features/cellular/framework/targets/UBLOX/LISA_U/: UBLOX_LISA_U.cpp UBLOX_LISA_U.h UBLOX_LISA_U_CellularNetwork.cpp UBLOX_LISA_U_CellularNetwork.h UBLOX_LISA_U_CellularPower.cpp UBLOX_LISA_U_CellularPower.h
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group mbed-semtech-lora-rf-drivers
    mbed-semtech-lora-rf-drivers/SX1272/: SX1272_LoRaRadio.cpp SX1272_LoRaRadio.h
    mbed-semtech-lora-rf-drivers/SX1272/registers/: sx1272Regs-Fsk.h sx1272Regs-LoRa.h
    mbed-semtech-lora-rf-drivers/SX1276/: SX1276_LoRaRadio.cpp SX1276_LoRaRadio.h
    mbed-semtech-lora-rf-drivers/SX1276/registers/: sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group skeletonMbed
    ./: main.cpp mbedtls_lora_config.h
    ./: mbed_config.h
