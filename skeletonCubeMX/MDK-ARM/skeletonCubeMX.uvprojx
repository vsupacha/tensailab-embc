# Keil uVision project skeletonCubeMX.uvprojx, settings and files
target skeletonCubeMX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: skeletonCubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx, USE_B_L072Z_LRWAN1, REGION_AS923
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\Middlewares\LoRaWAN\Core;..\Middlewares\LoRaWAN\Crypto;..\Middlewares\LoRaWAN\Mac;..\Middlewares\LoRaWAN\Mac\region;..\Middlewares\LoRaWAN\Phy;..\Middlewares\LoRaWAN\Utilities;..\Drivers\BSP\B-L072Z-LRWAN1;..\Drivers\BSP\CMWX1ZZABZ-0xx;..\Drivers\BSP\sx1276
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c vcom.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
  group Middlewares/LoRaWAN
    ../Middlewares/LoRaWAN/Core/: lora.c lora-test.c
    ../Middlewares/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
    ../Middlewares/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c
    ../Middlewares/LoRaWAN/Utilities/: low_power_manager.c queue.c systime.c timeServer.c trace.c utilities.c
    ../Middlewares/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Drivers/BSP
    ../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
    ../Drivers/BSP/CMWX1ZZABZ-0xx/: mlm32l07x01.c
    ../Drivers/BSP/sx1276/: sx1276.c
software components: CMSIS:CORE 4.3.0
